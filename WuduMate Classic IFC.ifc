Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2022-12-15T12:51:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220111_1110(x64) - Exporter 19.2.50.16 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Dec 15 12:51:17 2022 * Host: ws-73 * Database: C:\Users\SAM~1.MEL\AppData\Local\Temp\{E66F2AD5-8BBE-47A3-939A-F9F792DB044B}\ifc * Database version: 5507 * Database creation date: Thu Dec 15 12:51:16 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Dec 15 12:51:16 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Dec 15 12:51:16 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowTerminal: WuduMate_Classic, WuduMate_PlumbingFixtures_Baths_Classic:WuduMate_Classic:3401
In: Level 1
Classification: C1030210 (Uniformat); Material: WuduMate_Acrylic
Pset_ManufacturerTypeInformation - ModelReference: Classic; Manufacturer: WuduMate; ProductionYear: 2022
Pset_DistributionFlowElementCommon - Reference: WuduMate_Classic
Constraints - Offset: 0 mm
Dimensions - Area: 1.80264 m2; Volume: 0.237346 m3
Identity Data - Mark: 1
Mechanical - System Classification: Sanitary
Other - AssetIdentifier: n/a; BarCode: Please record on commissioning.; Category: Plumbing Fixtures; Family: WuduMate_PlumbingFixtures_Baths_Classic: WuduMate_Classic; Family and Type: WuduMate_PlumbingFixtures_Baths_Classic: WuduMate_Classic; InstallationDate: Please record on commissioning.; SerialNumber: Please record on commissioning.; Type: WuduMate_PlumbingFixtures_Baths_Classic: WuduMate_Classic; Type Id: WuduMate_PlumbingFixtures_Baths_Classic: WuduMate_Classic; WarrantyStartDate: Please record on commissioning.
Phasing - Phase Created: New Construction
Identity Data(Type) - Assembly Code: C1030210; Cost: 0; Description: WuduMate Classic is an easily installed wudu washing bowl for commercial buildings where inclusion and diversity matter, including multi-faith and prayer rooms in offices, schools, hospitals, prisons, public buildings and leisure venues.; Manufacturer: WuduMate; Model: Classic; Type Comments: Classic; Type Name: WuduMate_Classic; URL: https://wudumate.com/
Model Properties(Type) - _Author: SM; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 17; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/wudumate-classic/document/object-user-guide; BIMObjectName: WuduMate_PlumbingFixtures_Baths_Classic; NBSDescription: Baths; NBSNote: n/a; NBSObjectName: WuduMate - Baths; NBSOfficeMasterTag: n/a; NBSReference: Pr_40_20_06_08
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_06_08; CodePerformance: n/a; Color: White; Constituents: n/a; CreatedBy: info@wudumate.com; CreatedOn: 2022-11-22 T:09:00:00; DocumentationCertificates: https://www.bimstore.co/products/wudumate-classic/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/wudumate-classic/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/wudumate-classic/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/wudumate-classic/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/wudumate-classic/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: WuduMate_PlumbingFixtures_Baths_Classic; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: WuduMate; Material: Acrylic; ModelNumber: Classic; ModelReference: Classic; ProductionYear: 2022; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Classic; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: info@wudumate.com; WarrantyGuarantorParts: info@wudumate.com
